# IAR project SampleLight.ewp, settings and files
configuration ZAP Coordinator (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 512
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; ZAP_DEVICETYPE=ZG_DEVICETYPE_COORDINATOR
  ICC430.CCDiagSuppress: Pe001,Pe193,Pe236,Pe826
  ICC430.IExtraOptions: -f ..\..\Source\zap.cfg; -f ..\..\..\Tools\MSP5438\f8wZCL.cfg
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\..\..\Components\hal\target\MSP5438ZAP; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\osal\mcu\msp430; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\MSP5438\MSP430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration ZAP Router (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; ZAP_DEVICETYPE=ZG_DEVICETYPE_ROUTER
configuration ZAP EndDevice (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; ZAP_DEVICETYPE=ZG_DEVICETYPE_ENDDEVICE
  group App
    ../Source/: OSAL_SampleLight.c zcl_samplelight.c zcl_samplelight.h zcl_samplelight_data.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
    ../../../../../Components/hal/include/: hal_assert.h hal_defs.h hal_drivers.h
  group HAL/Drivers
    ../../../../../Components/hal/include/: hal_adc.h hal_key.h hal_lcd.h hal_led.h hal_timer.h hal_uart.h
  group HAL/Target/Config
    ../../../../../Components/hal/target/MSP5438ZAP/: hal_board.h hal_board_cfg.h hal_dco.c hal_dco.h hal_startup.c
  group HAL/Target/Drivers
    ../../../../../Components/hal/target/MSP5438ZAP/: hal_adc.c hal_board.c hal_key.c hal_lcd.c hal_led.c hal_main.c hal_spi.c hal_timer.c hal_uart.c
  group HAL/Target/Includes
    ../../../../../Components/hal/target/MSP5438ZAP/: hal_mcu.h hal_spi.h hal_types.h
  group MT
    ../../../../../Components/mt/: MT.h MT_AF.h MT_MAC.h MT_RPC.h MT_SYS.h MT_UART.h MT_UTIL.h MT_VERSION.h MT_ZDO.h
  group OSAL
    ../../../../../Components/osal/mcu/msp430/: MSP430FlashUtil.c MSP430FlashUtil.h OSAL_Nv.c
    ../../../../../Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/include/: OSAL.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group Profile
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_general.c zcl_general.h
    ../../Source/: zcl_ha.c zcl_ha.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
    ../../../../../Components/stack/sapi/: sapi.h
  group Tools
    ../../../Tools/MSP5438/: f8wZCL.cfg MSP430F5438.xcl
    ../../Source/: zap.cfg
  group ZAP
    ../../Source/: zap_af.c zap_app.c zap_app.h zap_phy.c zap_phy.h zap_sapi.c zap_sys.c zap_util.c zap_zdo.c zap_zmac.c zap_znp.c zap_znp.h
