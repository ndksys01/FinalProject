# IAR project bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  ICCARM.IExtraOptions: -f "bsp_iar.cfg"
  ICCARM.CCIncludePath2: ..\..\source; ..\..\..\..\..\driverlib\cc2538\inc; ..\..\..\..\..\driverlib\cc2538\bin\iar; ..\..\..\..\..\driverlib\cc2538\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: bsp_iar.cfg
  group source
    ../../source/: bsp.c bsp.h bsp_key.c bsp_led.c io_pin_int.c
